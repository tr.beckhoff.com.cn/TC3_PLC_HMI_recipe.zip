VAR_GLOBAL
	bRecipe:			BOOL;
	nRecipe:			INT;
	rRecipe:			REAL;
	aRecipe:			ARRAY[1..10] OF INT;
	sRecipe:			STRING;	
	TON_Recipe:			TON;
END_VAR
