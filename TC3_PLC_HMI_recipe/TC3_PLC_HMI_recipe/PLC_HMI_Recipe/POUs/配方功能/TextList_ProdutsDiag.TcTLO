TEXTLIST TextList_ProdutsDiag
  1 = '确定要替代配方'
  2 = '确定要删除配方'
   = ''
END_TEXTLIST
